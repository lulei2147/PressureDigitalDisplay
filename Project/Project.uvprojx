# Keil uVision project Project.uvprojx, settings and files
target STM32L151C8T6 (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00002800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32L1_StdPeriph_Driver\inc;..\User;..\User\debug;..\User\usart;..\User\sys;..\User\74hc595;..\User\dac;..\User\adc;..\User\key;..\User\tim;..\User\eeprom;..\User\iwdg;..\User\spi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group StdPeriphDriver
    ../Libraries/STM32L1_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group Startup
    ../Libraries/CMSIS/startup/: startup_stm32l1xx_hd.s startup_stm32l1xx_md.s startup_stm32l1xx_mdp.s startup_stm32l1xx_xl.s
  group CMSIS
    ../User/: system_stm32l1xx.c
  group User
    ../User/: main.c stm32l1xx_it.c user_menu.c
    ../User/debug/: debug.c
    ../User/usart/: usart.c receiveCmd.c
    ../User/74hc595/: LG3641AH.c
    ../User/dac/: dac.c
    ../User/adc/: adc.c
    ../User/key/: key.c
    ../User/tim/: tim.c
    ../User/sys/: sys.c
    ../User/eeprom/: eeprom.c eepromDefault.c
    ../User/iwdg/: iwdg.c
    ../User/spi/: spi.c NSA2860.c
  group Header
    ../User/: commonInclude.h main.h stm32l1xx_conf.h stm32l1xx_it.h user_menu.h
    ../User/usart/: usart.h receiveCmd.h
    ../User/tim/: tim.h
    ../User/sys/: sys.h General_type.h
    ../User/key/: key.h
    ../User/debug/: debug.h
    ../User/dac/: dac.h
    ../User/adc/: adc.h
    ../User/74hc595/: LG3641AH.h
    ../User/eeprom/: eeprom.h
    ../User/iwdg/: iwdg.h
    ../User/spi/: spi.h NSA2860.h
